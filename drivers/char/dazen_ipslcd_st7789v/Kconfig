## drivers/char/dazen_ipslcd_st7789v/Kconfig
```kconfig
config DAZEN_IPSLCD_ST7789V
    tristate  "dazen ipslcd_st7789v"
    help
    dazen ipslcd_st7789v help
```
